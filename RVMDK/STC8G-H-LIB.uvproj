# Keil uVision project STC8G-H-LIB.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: STC8G-H-LIB +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver\inc;..\User
  link misc: REMOVEUNUSED
  group User
    ./: STARTUP.A51
    ../User/: main.c Uart.c Tick.c
  group Driver
    ../Driver/src/: STC8G_H_ADC.c STC8G_H_Compare.c STC8G_H_Delay.c STC8G_H_EEPROM.c STC8G_H_Exti.c STC8G_H_GPIO.c STC8G_H_I2C.c STC8G_H_NVIC.c STC8G_H_Soft_I2C.c STC8G_H_Soft_UART.c STC8G_H_SPI.c STC8G_H_Timer.c STC8G_H_UART.c STC8G_H_WDT.c STC8G_PCA.c STC8G_PWM15bit.c STC8H_PWM.c STC8H_RTC.c
  group ISR
    ../Driver/isr/: STC8G_H_ADC_Isr.c STC8G_H_Compare_Isr.c STC8G_H_Exti_Isr.c STC8G_H_GPIO_Isr.c STC8G_H_I2C_Isr.c STC8G_H_SPI_Isr.c STC8G_H_Timer_Isr.c STC8G_H_UART_Isr.c STC8G_PCA_Isr.c STC8G_PWM15bit_Isr.c STC8H_PWM_Isr.c STC8H_RTC_Isr.c
